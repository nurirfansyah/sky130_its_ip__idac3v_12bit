v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {idac8bit_binary_cs.sym} -20 20 0 0 {name=x1}
C {idac4bit_unary_cs.sym} -20 290 0 0 {name=x2}
