v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N -50 -70 -20 -70 {
lab=din0}
N -50 -50 -20 -50 {
lab=din1}
N -50 -30 -20 -30 {
lab=din2}
N -50 -10 -20 -10 {
lab=din3}
N -50 10 -20 10 {
lab=din4}
N -50 30 -20 30 {
lab=din5}
N -50 90 -20 90 {
lab=din0_n}
N -50 110 -20 110 {
lab=din1_n}
N -50 130 -20 130 {
lab=din2_n}
N -50 150 -20 150 {
lab=din3_n}
N -50 170 -20 170 {
lab=din4_n}
N -50 190 -20 190 {
lab=din5_n}
N 180 -70 210 -70 {
lab=t0}
N 180 -50 210 -50 {
lab=t1}
N 180 -30 210 -30 {
lab=t2}
N 180 -10 210 -10 {
lab=t3}
N 180 10 210 10 {
lab=t4}
N 180 30 210 30 {
lab=t5}
N 180 50 210 50 {
lab=t6}
N 180 70 210 70 {
lab=t7}
N 320 -70 350 -70 {
lab=t0}
N 320 -50 350 -50 {
lab=t1}
N 320 -30 350 -30 {
lab=t2}
N 320 -10 350 -10 {
lab=t3}
N 320 10 350 10 {
lab=t4}
N 320 30 350 30 {
lab=t5}
N 320 50 350 50 {
lab=t6}
N 320 70 350 70 {
lab=t7}
C {devices/ipin.sym} -50 -70 0 0 {name=p1 lab=din0}
C {devices/ipin.sym} -50 -50 0 0 {name=p2 lab=din1}
C {devices/ipin.sym} -50 -30 0 0 {name=p3 lab=din2}
C {devices/ipin.sym} -50 -10 0 0 {name=p4 lab=din3}
C {devices/ipin.sym} -50 10 0 0 {name=p5 lab=din4}
C {devices/ipin.sym} -50 30 0 0 {name=p6 lab=din5}
C {devices/ipin.sym} -50 90 0 0 {name=p7 lab=din0_n}
C {devices/ipin.sym} -50 110 0 0 {name=p8 lab=din1_n}
C {devices/ipin.sym} -50 130 0 0 {name=p9 lab=din2_n}
C {devices/ipin.sym} -50 150 0 0 {name=p10 lab=din3_n}
C {devices/ipin.sym} -50 170 0 0 {name=p11 lab=din4_n}
C {devices/ipin.sym} -50 190 0 0 {name=p12 lab=din5_n}
C {devices/opin.sym} 210 -70 0 0 {name=p13 lab=t0}
C {devices/opin.sym} 210 -50 0 0 {name=p14 lab=t1}
C {devices/opin.sym} 210 -30 0 0 {name=p15 lab=t2}
C {devices/opin.sym} 210 -10 0 0 {name=p16 lab=t3}
C {devices/opin.sym} 210 10 0 0 {name=p17 lab=t4}
C {devices/opin.sym} 210 30 0 0 {name=p18 lab=t5}
C {devices/opin.sym} 210 50 0 0 {name=p19 lab=t6}
C {devices/opin.sym} 210 70 0 0 {name=p20 lab=t7}
C {devices/lab_pin.sym} 180 -70 0 0 {name=p21 sig_type=std_logic lab=t0}
C {devices/lab_pin.sym} 180 -50 0 0 {name=p22 sig_type=std_logic lab=t1}
C {devices/lab_pin.sym} 180 -30 0 0 {name=p23 sig_type=std_logic lab=t2}
C {devices/lab_pin.sym} 180 -10 0 0 {name=p24 sig_type=std_logic lab=t3}
C {devices/lab_pin.sym} 180 10 0 0 {name=p25 sig_type=std_logic lab=t4}
C {devices/lab_pin.sym} 180 30 0 0 {name=p26 sig_type=std_logic lab=t5}
C {devices/lab_pin.sym} 180 50 0 0 {name=p27 sig_type=std_logic lab=t6}
C {devices/lab_pin.sym} 180 70 0 0 {name=p28 sig_type=std_logic lab=t7}
C {devices/lab_pin.sym} -20 -70 0 1 {name=p29 sig_type=std_logic lab=din0}
C {devices/lab_pin.sym} -20 -50 0 1 {name=p30 sig_type=std_logic lab=din1}
C {devices/lab_pin.sym} -20 -30 0 1 {name=p31 sig_type=std_logic lab=din2}
C {devices/lab_pin.sym} -20 -10 0 1 {name=p32 sig_type=std_logic lab=din3}
C {devices/lab_pin.sym} -20 10 0 1 {name=p33 sig_type=std_logic lab=din4}
C {devices/lab_pin.sym} -20 30 0 1 {name=p34 sig_type=std_logic lab=din5}
C {devices/lab_pin.sym} -20 90 0 1 {name=p35 sig_type=std_logic lab=din0_n}
C {devices/lab_pin.sym} -20 110 0 1 {name=p36 sig_type=std_logic lab=din1_n}
C {devices/lab_pin.sym} -20 130 0 1 {name=p37 sig_type=std_logic lab=din2_n}
C {devices/lab_pin.sym} -20 150 0 1 {name=p38 sig_type=std_logic lab=din3_n}
C {devices/lab_pin.sym} -20 170 0 1 {name=p39 sig_type=std_logic lab=din4_n}
C {devices/lab_pin.sym} -20 190 0 1 {name=p40 sig_type=std_logic lab=din5_n}
C {devices/opin.sym} 350 -70 0 0 {name=p41 lab=t8}
C {devices/opin.sym} 350 -50 0 0 {name=p42 lab=t9}
C {devices/opin.sym} 350 -30 0 0 {name=p43 lab=t10}
C {devices/opin.sym} 350 -10 0 0 {name=p44 lab=t11}
C {devices/opin.sym} 350 10 0 0 {name=p45 lab=t12}
C {devices/opin.sym} 350 30 0 0 {name=p46 lab=t13}
C {devices/opin.sym} 350 50 0 0 {name=p47 lab=t14}
C {devices/opin.sym} 350 70 0 0 {name=p48 lab=t15}
C {devices/lab_pin.sym} 320 -70 0 0 {name=p49 sig_type=std_logic lab=t8}
C {devices/lab_pin.sym} 320 -50 0 0 {name=p50 sig_type=std_logic lab=t9}
C {devices/lab_pin.sym} 320 -30 0 0 {name=p51 sig_type=std_logic lab=t10}
C {devices/lab_pin.sym} 320 -10 0 0 {name=p52 sig_type=std_logic lab=t11}
C {devices/lab_pin.sym} 320 10 0 0 {name=p53 sig_type=std_logic lab=t12}
C {devices/lab_pin.sym} 320 30 0 0 {name=p54 sig_type=std_logic lab=t13}
C {devices/lab_pin.sym} 320 50 0 0 {name=p55 sig_type=std_logic lab=t14}
C {devices/lab_pin.sym} 320 70 0 0 {name=p56 sig_type=std_logic lab=t15}
