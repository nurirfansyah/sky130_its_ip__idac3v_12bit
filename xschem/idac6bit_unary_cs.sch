v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N -50 150 -20 150 {
lab=avss}
N -50 130 -20 130 {
lab=nbias}
N -50 110 -20 110 {
lab=ncbias}
N -50 90 -20 90 {
lab=idir_sel}
N -50 70 -20 70 {
lab=pcbias}
N -50 50 -20 50 {
lab=sw0}
N -50 30 -20 30 {
lab=pbias}
N -50 10 -20 10 {
lab=avdd}
N 280 10 310 10 {
lab=iout}
N 280 30 310 30 {
lab=xxx}
N -50 340 -20 340 {
lab=avss}
N -50 320 -20 320 {
lab=nbias}
N -50 300 -20 300 {
lab=ncbias}
N -50 280 -20 280 {
lab=idir_sel}
N -50 260 -20 260 {
lab=pcbias}
N -50 240 -20 240 {
lab=sw0}
N -50 220 -20 220 {
lab=pbias}
N -50 200 -20 200 {
lab=avdd}
N 280 200 310 200 {
lab=iout}
N 280 220 310 220 {
lab=xxx}
N -50 530 -20 530 {
lab=avss}
N -50 510 -20 510 {
lab=nbias}
N -50 490 -20 490 {
lab=ncbias}
N -50 470 -20 470 {
lab=idir_sel}
N -50 450 -20 450 {
lab=pcbias}
N -50 430 -20 430 {
lab=sw0}
N -50 410 -20 410 {
lab=pbias}
N -50 390 -20 390 {
lab=avdd}
N 280 390 310 390 {
lab=iout}
N 280 410 310 410 {
lab=xxx}
N -50 730 -20 730 {
lab=avss}
N -50 710 -20 710 {
lab=nbias}
N -50 690 -20 690 {
lab=ncbias}
N -50 670 -20 670 {
lab=idir_sel}
N -50 650 -20 650 {
lab=pcbias}
N -50 630 -20 630 {
lab=sw0}
N -50 610 -20 610 {
lab=pbias}
N -50 590 -20 590 {
lab=avdd}
N 280 590 310 590 {
lab=iout}
N 280 610 310 610 {
lab=xxx}
N -50 930 -20 930 {
lab=avss}
N -50 910 -20 910 {
lab=nbias}
N -50 890 -20 890 {
lab=ncbias}
N -50 870 -20 870 {
lab=idir_sel}
N -50 850 -20 850 {
lab=pcbias}
N -50 830 -20 830 {
lab=sw0}
N -50 810 -20 810 {
lab=pbias}
N -50 790 -20 790 {
lab=avdd}
N 280 790 310 790 {
lab=iout}
N 280 810 310 810 {
lab=xxx}
N -50 1120 -20 1120 {
lab=avss}
N -50 1100 -20 1100 {
lab=nbias}
N -50 1080 -20 1080 {
lab=ncbias}
N -50 1060 -20 1060 {
lab=idir_sel}
N -50 1040 -20 1040 {
lab=pcbias}
N -50 1020 -20 1020 {
lab=sw0}
N -50 1000 -20 1000 {
lab=pbias}
N -50 980 -20 980 {
lab=avdd}
N 280 980 310 980 {
lab=iout}
N 280 1000 310 1000 {
lab=xxx}
N -50 1310 -20 1310 {
lab=avss}
N -50 1290 -20 1290 {
lab=nbias}
N -50 1270 -20 1270 {
lab=ncbias}
N -50 1250 -20 1250 {
lab=idir_sel}
N -50 1230 -20 1230 {
lab=pcbias}
N -50 1210 -20 1210 {
lab=sw0}
N -50 1190 -20 1190 {
lab=pbias}
N -50 1170 -20 1170 {
lab=avdd}
N 280 1170 310 1170 {
lab=iout}
N 280 1190 310 1190 {
lab=xxx}
N -50 1510 -20 1510 {
lab=avss}
N -50 1490 -20 1490 {
lab=nbias}
N -50 1470 -20 1470 {
lab=ncbias}
N -50 1450 -20 1450 {
lab=idir_sel}
N -50 1430 -20 1430 {
lab=pcbias}
N -50 1410 -20 1410 {
lab=sw0}
N -50 1390 -20 1390 {
lab=pbias}
N -50 1370 -20 1370 {
lab=avdd}
N 280 1370 310 1370 {
lab=iout}
N 280 1390 310 1390 {
lab=xxx}
N 590 1520 620 1520 {
lab=avss}
N 590 1500 620 1500 {
lab=nbias}
N 590 1480 620 1480 {
lab=ncbias}
N 590 1460 620 1460 {
lab=idir_sel}
N 590 1440 620 1440 {
lab=pcbias}
N 590 1420 620 1420 {
lab=sw0}
N 590 1400 620 1400 {
lab=pbias}
N 920 1400 950 1400 {
lab=xxx}
N 1210 160 1240 160 {
lab=avss}
N 1210 140 1240 140 {
lab=nbias}
N 1210 120 1240 120 {
lab=ncbias}
N 1210 100 1240 100 {
lab=idir_sel}
N 1210 80 1240 80 {
lab=pcbias}
N 1210 60 1240 60 {
lab=sw0}
N 1210 40 1240 40 {
lab=pbias}
N 1210 20 1240 20 {
lab=avdd}
N 1540 20 1570 20 {
lab=iout}
N 1540 40 1570 40 {
lab=xxx}
N 1210 350 1240 350 {
lab=avss}
N 1210 330 1240 330 {
lab=nbias}
N 1210 310 1240 310 {
lab=ncbias}
N 1210 290 1240 290 {
lab=idir_sel}
N 1210 270 1240 270 {
lab=pcbias}
N 1210 250 1240 250 {
lab=sw0}
N 1210 230 1240 230 {
lab=pbias}
N 1210 210 1240 210 {
lab=avdd}
N 1540 210 1570 210 {
lab=iout}
N 1540 230 1570 230 {
lab=xxx}
N 1210 540 1240 540 {
lab=avss}
N 1210 520 1240 520 {
lab=nbias}
N 1210 500 1240 500 {
lab=ncbias}
N 1210 480 1240 480 {
lab=idir_sel}
N 1210 460 1240 460 {
lab=pcbias}
N 1210 440 1240 440 {
lab=sw0}
N 1210 420 1240 420 {
lab=pbias}
N 1210 400 1240 400 {
lab=avdd}
N 1540 400 1570 400 {
lab=iout}
N 1540 420 1570 420 {
lab=xxx}
N 1210 740 1240 740 {
lab=avss}
N 1210 720 1240 720 {
lab=nbias}
N 1210 700 1240 700 {
lab=ncbias}
N 1210 680 1240 680 {
lab=idir_sel}
N 1210 660 1240 660 {
lab=pcbias}
N 1210 640 1240 640 {
lab=sw0}
N 1210 620 1240 620 {
lab=pbias}
N 1210 600 1240 600 {
lab=avdd}
N 1540 600 1570 600 {
lab=iout}
N 1540 620 1570 620 {
lab=xxx}
N 1210 940 1240 940 {
lab=avss}
N 1210 920 1240 920 {
lab=nbias}
N 1210 900 1240 900 {
lab=ncbias}
N 1210 880 1240 880 {
lab=idir_sel}
N 1210 860 1240 860 {
lab=pcbias}
N 1210 840 1240 840 {
lab=sw0}
N 1210 820 1240 820 {
lab=pbias}
N 1210 800 1240 800 {
lab=avdd}
N 1540 800 1570 800 {
lab=iout}
N 1540 820 1570 820 {
lab=xxx}
N 1210 1130 1240 1130 {
lab=avss}
N 1210 1110 1240 1110 {
lab=nbias}
N 1210 1090 1240 1090 {
lab=ncbias}
N 1210 1070 1240 1070 {
lab=idir_sel}
N 1210 1050 1240 1050 {
lab=pcbias}
N 1210 1030 1240 1030 {
lab=sw0}
N 1210 1010 1240 1010 {
lab=pbias}
N 1210 990 1240 990 {
lab=avdd}
N 1540 990 1570 990 {
lab=iout}
N 1540 1010 1570 1010 {
lab=xxx}
N 1210 1320 1240 1320 {
lab=avss}
N 1210 1300 1240 1300 {
lab=nbias}
N 1210 1280 1240 1280 {
lab=ncbias}
N 1210 1260 1240 1260 {
lab=idir_sel}
N 1210 1240 1240 1240 {
lab=pcbias}
N 1210 1220 1240 1220 {
lab=sw0}
N 1210 1200 1240 1200 {
lab=pbias}
N 1210 1180 1240 1180 {
lab=avdd}
N 1540 1180 1570 1180 {
lab=iout}
N 1540 1200 1570 1200 {
lab=xxx}
N 1210 1520 1240 1520 {
lab=avss}
N 1210 1500 1240 1500 {
lab=nbias}
N 1210 1480 1240 1480 {
lab=ncbias}
N 1210 1460 1240 1460 {
lab=idir_sel}
N 1210 1440 1240 1440 {
lab=pcbias}
N 1210 1420 1240 1420 {
lab=sw0}
N 1210 1400 1240 1400 {
lab=pbias}
N 1210 1380 1240 1380 {
lab=avdd}
N 1540 1380 1570 1380 {
lab=iout}
N 1540 1400 1570 1400 {
lab=xxx}
N 1850 160 1880 160 {
lab=avss}
N 1850 140 1880 140 {
lab=nbias}
N 1850 120 1880 120 {
lab=ncbias}
N 1850 100 1880 100 {
lab=idir_sel}
N 1850 80 1880 80 {
lab=pcbias}
N 1850 60 1880 60 {
lab=sw0}
N 1850 40 1880 40 {
lab=pbias}
N 1850 20 1880 20 {
lab=avdd}
N 2180 20 2210 20 {
lab=iout}
N 2180 40 2210 40 {
lab=xxx}
N 1850 350 1880 350 {
lab=avss}
N 1850 330 1880 330 {
lab=nbias}
N 1850 310 1880 310 {
lab=ncbias}
N 1850 290 1880 290 {
lab=idir_sel}
N 1850 270 1880 270 {
lab=pcbias}
N 1850 250 1880 250 {
lab=sw0}
N 1850 230 1880 230 {
lab=pbias}
N 1850 210 1880 210 {
lab=avdd}
N 2180 210 2210 210 {
lab=iout}
N 2180 230 2210 230 {
lab=xxx}
N 1850 540 1880 540 {
lab=avss}
N 1850 520 1880 520 {
lab=nbias}
N 1850 500 1880 500 {
lab=ncbias}
N 1850 480 1880 480 {
lab=idir_sel}
N 1850 460 1880 460 {
lab=pcbias}
N 1850 440 1880 440 {
lab=sw0}
N 1850 420 1880 420 {
lab=pbias}
N 1850 400 1880 400 {
lab=avdd}
N 2180 400 2210 400 {
lab=iout}
N 2180 420 2210 420 {
lab=xxx}
N 1850 740 1880 740 {
lab=avss}
N 1850 720 1880 720 {
lab=nbias}
N 1850 700 1880 700 {
lab=ncbias}
N 1850 680 1880 680 {
lab=idir_sel}
N 1850 660 1880 660 {
lab=pcbias}
N 1850 640 1880 640 {
lab=sw0}
N 1850 620 1880 620 {
lab=pbias}
N 1850 600 1880 600 {
lab=avdd}
N 2180 600 2210 600 {
lab=iout}
N 2180 620 2210 620 {
lab=xxx}
N 1850 940 1880 940 {
lab=avss}
N 1850 920 1880 920 {
lab=nbias}
N 1850 900 1880 900 {
lab=ncbias}
N 1850 880 1880 880 {
lab=idir_sel}
N 1850 860 1880 860 {
lab=pcbias}
N 1850 840 1880 840 {
lab=sw0}
N 1850 820 1880 820 {
lab=pbias}
N 1850 800 1880 800 {
lab=avdd}
N 2180 800 2210 800 {
lab=iout}
N 2180 820 2210 820 {
lab=xxx}
N 1850 1130 1880 1130 {
lab=avss}
N 1850 1110 1880 1110 {
lab=nbias}
N 1850 1090 1880 1090 {
lab=ncbias}
N 1850 1070 1880 1070 {
lab=idir_sel}
N 1850 1050 1880 1050 {
lab=pcbias}
N 1850 1030 1880 1030 {
lab=sw0}
N 1850 1010 1880 1010 {
lab=pbias}
N 1850 990 1880 990 {
lab=avdd}
N 2180 990 2210 990 {
lab=iout}
N 2180 1010 2210 1010 {
lab=xxx}
N 1850 1320 1880 1320 {
lab=avss}
N 1850 1300 1880 1300 {
lab=nbias}
N 1850 1280 1880 1280 {
lab=ncbias}
N 1850 1260 1880 1260 {
lab=idir_sel}
N 1850 1240 1880 1240 {
lab=pcbias}
N 1850 1220 1880 1220 {
lab=sw0}
N 1850 1200 1880 1200 {
lab=pbias}
N 1850 1180 1880 1180 {
lab=avdd}
N 2180 1180 2210 1180 {
lab=iout}
N 2180 1200 2210 1200 {
lab=xxx}
N 1850 1520 1880 1520 {
lab=avss}
N 1850 1500 1880 1500 {
lab=nbias}
N 1850 1480 1880 1480 {
lab=ncbias}
N 1850 1460 1880 1460 {
lab=idir_sel}
N 1850 1440 1880 1440 {
lab=pcbias}
N 1850 1420 1880 1420 {
lab=sw0}
N 1850 1400 1880 1400 {
lab=pbias}
N 1850 1380 1880 1380 {
lab=avdd}
N 2180 1380 2210 1380 {
lab=iout}
N 2180 1400 2210 1400 {
lab=xxx}
N 2410 150 2440 150 {
lab=avss}
N 2410 130 2440 130 {
lab=nbias}
N 2410 110 2440 110 {
lab=ncbias}
N 2410 90 2440 90 {
lab=idir_sel}
N 2410 70 2440 70 {
lab=pcbias}
N 2410 50 2440 50 {
lab=sw0}
N 2410 30 2440 30 {
lab=pbias}
N 2410 10 2440 10 {
lab=avdd}
N 2740 10 2770 10 {
lab=iout}
N 2740 30 2770 30 {
lab=xxx}
N 2410 340 2440 340 {
lab=avss}
N 2410 320 2440 320 {
lab=nbias}
N 2410 300 2440 300 {
lab=ncbias}
N 2410 280 2440 280 {
lab=idir_sel}
N 2410 260 2440 260 {
lab=pcbias}
N 2410 240 2440 240 {
lab=sw0}
N 2410 220 2440 220 {
lab=pbias}
N 2410 200 2440 200 {
lab=avdd}
N 2740 200 2770 200 {
lab=iout}
N 2740 220 2770 220 {
lab=xxx}
N 2410 530 2440 530 {
lab=avss}
N 2410 510 2440 510 {
lab=nbias}
N 2410 490 2440 490 {
lab=ncbias}
N 2410 470 2440 470 {
lab=idir_sel}
N 2410 450 2440 450 {
lab=pcbias}
N 2410 430 2440 430 {
lab=sw0}
N 2410 410 2440 410 {
lab=pbias}
N 2410 390 2440 390 {
lab=avdd}
N 2740 390 2770 390 {
lab=iout}
N 2740 410 2770 410 {
lab=xxx}
N 2410 730 2440 730 {
lab=avss}
N 2410 710 2440 710 {
lab=nbias}
N 2410 690 2440 690 {
lab=ncbias}
N 2410 670 2440 670 {
lab=idir_sel}
N 2410 650 2440 650 {
lab=pcbias}
N 2410 630 2440 630 {
lab=sw0}
N 2410 610 2440 610 {
lab=pbias}
N 2410 590 2440 590 {
lab=avdd}
N 2740 590 2770 590 {
lab=iout}
N 2740 610 2770 610 {
lab=xxx}
N 2410 930 2440 930 {
lab=avss}
N 2410 910 2440 910 {
lab=nbias}
N 2410 890 2440 890 {
lab=ncbias}
N 2410 870 2440 870 {
lab=idir_sel}
N 2410 850 2440 850 {
lab=pcbias}
N 2410 830 2440 830 {
lab=sw0}
N 2410 810 2440 810 {
lab=pbias}
N 2410 790 2440 790 {
lab=avdd}
N 2740 790 2770 790 {
lab=iout}
N 2740 810 2770 810 {
lab=xxx}
N 2410 1120 2440 1120 {
lab=avss}
N 2410 1100 2440 1100 {
lab=nbias}
N 2410 1080 2440 1080 {
lab=ncbias}
N 2410 1060 2440 1060 {
lab=idir_sel}
N 2410 1040 2440 1040 {
lab=pcbias}
N 2410 1020 2440 1020 {
lab=sw0}
N 2410 1000 2440 1000 {
lab=pbias}
N 2410 980 2440 980 {
lab=avdd}
N 2740 980 2770 980 {
lab=iout}
N 2740 1000 2770 1000 {
lab=xxx}
N 2410 1310 2440 1310 {
lab=avss}
N 2410 1290 2440 1290 {
lab=nbias}
N 2410 1270 2440 1270 {
lab=ncbias}
N 2410 1250 2440 1250 {
lab=idir_sel}
N 2410 1230 2440 1230 {
lab=pcbias}
N 2410 1210 2440 1210 {
lab=sw0}
N 2410 1190 2440 1190 {
lab=pbias}
N 2410 1170 2440 1170 {
lab=avdd}
N 2740 1170 2770 1170 {
lab=iout}
N 2740 1190 2770 1190 {
lab=xxx}
N 2410 1510 2440 1510 {
lab=avss}
N 2410 1490 2440 1490 {
lab=nbias}
N 2410 1470 2440 1470 {
lab=ncbias}
N 2410 1450 2440 1450 {
lab=idir_sel}
N 2410 1430 2440 1430 {
lab=pcbias}
N 2410 1410 2440 1410 {
lab=sw0}
N 2410 1390 2440 1390 {
lab=pbias}
N 2410 1370 2440 1370 {
lab=avdd}
N 2740 1370 2770 1370 {
lab=iout}
N 2740 1390 2770 1390 {
lab=xxx}
N 3050 160 3080 160 {
lab=avss}
N 3050 140 3080 140 {
lab=nbias}
N 3050 120 3080 120 {
lab=ncbias}
N 3050 100 3080 100 {
lab=idir_sel}
N 3050 80 3080 80 {
lab=pcbias}
N 3050 60 3080 60 {
lab=sw0}
N 3050 40 3080 40 {
lab=pbias}
N 3050 20 3080 20 {
lab=avdd}
N 3380 20 3410 20 {
lab=iout}
N 3380 40 3410 40 {
lab=xxx}
N 3050 350 3080 350 {
lab=avss}
N 3050 330 3080 330 {
lab=nbias}
N 3050 310 3080 310 {
lab=ncbias}
N 3050 290 3080 290 {
lab=idir_sel}
N 3050 270 3080 270 {
lab=pcbias}
N 3050 250 3080 250 {
lab=sw0}
N 3050 230 3080 230 {
lab=pbias}
N 3050 210 3080 210 {
lab=avdd}
N 3380 210 3410 210 {
lab=iout}
N 3380 230 3410 230 {
lab=xxx}
N 3050 540 3080 540 {
lab=avss}
N 3050 520 3080 520 {
lab=nbias}
N 3050 500 3080 500 {
lab=ncbias}
N 3050 480 3080 480 {
lab=idir_sel}
N 3050 460 3080 460 {
lab=pcbias}
N 3050 440 3080 440 {
lab=sw0}
N 3050 420 3080 420 {
lab=pbias}
N 3050 400 3080 400 {
lab=avdd}
N 3380 400 3410 400 {
lab=iout}
N 3380 420 3410 420 {
lab=xxx}
N 3050 740 3080 740 {
lab=avss}
N 3050 720 3080 720 {
lab=nbias}
N 3050 700 3080 700 {
lab=ncbias}
N 3050 680 3080 680 {
lab=idir_sel}
N 3050 660 3080 660 {
lab=pcbias}
N 3050 640 3080 640 {
lab=sw0}
N 3050 620 3080 620 {
lab=pbias}
N 3050 600 3080 600 {
lab=avdd}
N 3380 600 3410 600 {
lab=iout}
N 3380 620 3410 620 {
lab=xxx}
N 3050 940 3080 940 {
lab=avss}
N 3050 920 3080 920 {
lab=nbias}
N 3050 900 3080 900 {
lab=ncbias}
N 3050 880 3080 880 {
lab=idir_sel}
N 3050 860 3080 860 {
lab=pcbias}
N 3050 840 3080 840 {
lab=sw0}
N 3050 820 3080 820 {
lab=pbias}
N 3050 800 3080 800 {
lab=avdd}
N 3380 800 3410 800 {
lab=iout}
N 3380 820 3410 820 {
lab=xxx}
N 3050 1130 3080 1130 {
lab=avss}
N 3050 1110 3080 1110 {
lab=nbias}
N 3050 1090 3080 1090 {
lab=ncbias}
N 3050 1070 3080 1070 {
lab=idir_sel}
N 3050 1050 3080 1050 {
lab=pcbias}
N 3050 1030 3080 1030 {
lab=sw0}
N 3050 1010 3080 1010 {
lab=pbias}
N 3050 990 3080 990 {
lab=avdd}
N 3380 990 3410 990 {
lab=iout}
N 3380 1010 3410 1010 {
lab=xxx}
N 3050 1320 3080 1320 {
lab=avss}
N 3050 1300 3080 1300 {
lab=nbias}
N 3050 1280 3080 1280 {
lab=ncbias}
N 3050 1260 3080 1260 {
lab=idir_sel}
N 3050 1240 3080 1240 {
lab=pcbias}
N 3050 1220 3080 1220 {
lab=sw0}
N 3050 1200 3080 1200 {
lab=pbias}
N 3050 1180 3080 1180 {
lab=avdd}
N 3380 1180 3410 1180 {
lab=iout}
N 3380 1200 3410 1200 {
lab=xxx}
N 3050 1520 3080 1520 {
lab=avss}
N 3050 1500 3080 1500 {
lab=nbias}
N 3050 1480 3080 1480 {
lab=ncbias}
N 3050 1460 3080 1460 {
lab=idir_sel}
N 3050 1440 3080 1440 {
lab=pcbias}
N 3050 1420 3080 1420 {
lab=sw0}
N 3050 1400 3080 1400 {
lab=pbias}
N 3050 1380 3080 1380 {
lab=avdd}
N 3380 1380 3410 1380 {
lab=iout}
N 3380 1400 3410 1400 {
lab=xxx}
N 3670 160 3700 160 {
lab=avss}
N 3670 140 3700 140 {
lab=nbias}
N 3670 120 3700 120 {
lab=ncbias}
N 3670 100 3700 100 {
lab=idir_sel}
N 3670 80 3700 80 {
lab=pcbias}
N 3670 60 3700 60 {
lab=sw0}
N 3670 40 3700 40 {
lab=pbias}
N 3670 20 3700 20 {
lab=avdd}
N 4000 20 4030 20 {
lab=iout}
N 4000 40 4030 40 {
lab=xxx}
N 3670 350 3700 350 {
lab=avss}
N 3670 330 3700 330 {
lab=nbias}
N 3670 310 3700 310 {
lab=ncbias}
N 3670 290 3700 290 {
lab=idir_sel}
N 3670 270 3700 270 {
lab=pcbias}
N 3670 250 3700 250 {
lab=sw0}
N 3670 230 3700 230 {
lab=pbias}
N 3670 210 3700 210 {
lab=avdd}
N 4000 210 4030 210 {
lab=iout}
N 4000 230 4030 230 {
lab=xxx}
N 3670 540 3700 540 {
lab=avss}
N 3670 520 3700 520 {
lab=nbias}
N 3670 500 3700 500 {
lab=ncbias}
N 3670 480 3700 480 {
lab=idir_sel}
N 3670 460 3700 460 {
lab=pcbias}
N 3670 440 3700 440 {
lab=sw0}
N 3670 420 3700 420 {
lab=pbias}
N 3670 400 3700 400 {
lab=avdd}
N 4000 400 4030 400 {
lab=iout}
N 4000 420 4030 420 {
lab=xxx}
N 3670 740 3700 740 {
lab=avss}
N 3670 720 3700 720 {
lab=nbias}
N 3670 700 3700 700 {
lab=ncbias}
N 3670 680 3700 680 {
lab=idir_sel}
N 3670 660 3700 660 {
lab=pcbias}
N 3670 640 3700 640 {
lab=sw0}
N 3670 620 3700 620 {
lab=pbias}
N 3670 600 3700 600 {
lab=avdd}
N 4000 600 4030 600 {
lab=iout}
N 4000 620 4030 620 {
lab=xxx}
N 3670 940 3700 940 {
lab=avss}
N 3670 920 3700 920 {
lab=nbias}
N 3670 900 3700 900 {
lab=ncbias}
N 3670 880 3700 880 {
lab=idir_sel}
N 3670 860 3700 860 {
lab=pcbias}
N 3670 840 3700 840 {
lab=sw0}
N 3670 820 3700 820 {
lab=pbias}
N 3670 800 3700 800 {
lab=avdd}
N 4000 800 4030 800 {
lab=iout}
N 4000 820 4030 820 {
lab=xxx}
N 3670 1130 3700 1130 {
lab=avss}
N 3670 1110 3700 1110 {
lab=nbias}
N 3670 1090 3700 1090 {
lab=ncbias}
N 3670 1070 3700 1070 {
lab=idir_sel}
N 3670 1050 3700 1050 {
lab=pcbias}
N 3670 1030 3700 1030 {
lab=sw0}
N 3670 1010 3700 1010 {
lab=pbias}
N 3670 990 3700 990 {
lab=avdd}
N 4000 990 4030 990 {
lab=iout}
N 4000 1010 4030 1010 {
lab=xxx}
N 3670 1320 3700 1320 {
lab=avss}
N 3670 1300 3700 1300 {
lab=nbias}
N 3670 1280 3700 1280 {
lab=ncbias}
N 3670 1260 3700 1260 {
lab=idir_sel}
N 3670 1240 3700 1240 {
lab=pcbias}
N 3670 1220 3700 1220 {
lab=sw0}
N 3670 1200 3700 1200 {
lab=pbias}
N 3670 1180 3700 1180 {
lab=avdd}
N 4000 1180 4030 1180 {
lab=iout}
N 4000 1200 4030 1200 {
lab=xxx}
N 3670 1520 3700 1520 {
lab=avss}
N 3670 1500 3700 1500 {
lab=nbias}
N 3670 1480 3700 1480 {
lab=ncbias}
N 3670 1460 3700 1460 {
lab=idir_sel}
N 3670 1440 3700 1440 {
lab=pcbias}
N 3670 1420 3700 1420 {
lab=sw0}
N 3670 1400 3700 1400 {
lab=pbias}
N 3670 1380 3700 1380 {
lab=avdd}
N 4000 1380 4030 1380 {
lab=iout}
N 4000 1400 4030 1400 {
lab=xxx}
N 4310 160 4340 160 {
lab=avss}
N 4310 140 4340 140 {
lab=nbias}
N 4310 120 4340 120 {
lab=ncbias}
N 4310 100 4340 100 {
lab=idir_sel}
N 4310 80 4340 80 {
lab=pcbias}
N 4310 60 4340 60 {
lab=sw0}
N 4310 40 4340 40 {
lab=pbias}
N 4310 20 4340 20 {
lab=avdd}
N 4640 20 4670 20 {
lab=iout}
N 4640 40 4670 40 {
lab=xxx}
N 4310 350 4340 350 {
lab=avss}
N 4310 330 4340 330 {
lab=nbias}
N 4310 310 4340 310 {
lab=ncbias}
N 4310 290 4340 290 {
lab=idir_sel}
N 4310 270 4340 270 {
lab=pcbias}
N 4310 250 4340 250 {
lab=sw0}
N 4310 230 4340 230 {
lab=pbias}
N 4310 210 4340 210 {
lab=avdd}
N 4640 210 4670 210 {
lab=iout}
N 4640 230 4670 230 {
lab=xxx}
N 4310 540 4340 540 {
lab=avss}
N 4310 520 4340 520 {
lab=nbias}
N 4310 500 4340 500 {
lab=ncbias}
N 4310 480 4340 480 {
lab=idir_sel}
N 4310 460 4340 460 {
lab=pcbias}
N 4310 440 4340 440 {
lab=sw0}
N 4310 420 4340 420 {
lab=pbias}
N 4310 400 4340 400 {
lab=avdd}
N 4640 400 4670 400 {
lab=iout}
N 4640 420 4670 420 {
lab=xxx}
N 4310 740 4340 740 {
lab=avss}
N 4310 720 4340 720 {
lab=nbias}
N 4310 700 4340 700 {
lab=ncbias}
N 4310 680 4340 680 {
lab=idir_sel}
N 4310 660 4340 660 {
lab=pcbias}
N 4310 640 4340 640 {
lab=sw0}
N 4310 620 4340 620 {
lab=pbias}
N 4310 600 4340 600 {
lab=avdd}
N 4640 600 4670 600 {
lab=iout}
N 4640 620 4670 620 {
lab=xxx}
N 4310 940 4340 940 {
lab=avss}
N 4310 920 4340 920 {
lab=nbias}
N 4310 900 4340 900 {
lab=ncbias}
N 4310 880 4340 880 {
lab=idir_sel}
N 4310 860 4340 860 {
lab=pcbias}
N 4310 840 4340 840 {
lab=sw0}
N 4310 820 4340 820 {
lab=pbias}
N 4310 800 4340 800 {
lab=avdd}
N 4640 800 4670 800 {
lab=iout}
N 4640 820 4670 820 {
lab=xxx}
N 4310 1130 4340 1130 {
lab=avss}
N 4310 1110 4340 1110 {
lab=nbias}
N 4310 1090 4340 1090 {
lab=ncbias}
N 4310 1070 4340 1070 {
lab=idir_sel}
N 4310 1050 4340 1050 {
lab=pcbias}
N 4310 1030 4340 1030 {
lab=sw0}
N 4310 1010 4340 1010 {
lab=pbias}
N 4310 990 4340 990 {
lab=avdd}
N 4640 990 4670 990 {
lab=iout}
N 4640 1010 4670 1010 {
lab=xxx}
N 4310 1320 4340 1320 {
lab=avss}
N 4310 1300 4340 1300 {
lab=nbias}
N 4310 1280 4340 1280 {
lab=ncbias}
N 4310 1260 4340 1260 {
lab=idir_sel}
N 4310 1240 4340 1240 {
lab=pcbias}
N 4310 1220 4340 1220 {
lab=sw0}
N 4310 1200 4340 1200 {
lab=pbias}
N 4310 1180 4340 1180 {
lab=avdd}
N 4640 1180 4670 1180 {
lab=iout}
N 4640 1200 4670 1200 {
lab=xxx}
N 4310 1520 4340 1520 {
lab=avss}
N 4310 1500 4340 1500 {
lab=nbias}
N 4310 1480 4340 1480 {
lab=ncbias}
N 4310 1460 4340 1460 {
lab=idir_sel}
N 4310 1440 4340 1440 {
lab=pcbias}
N 4310 1420 4340 1420 {
lab=sw0}
N 4310 1400 4340 1400 {
lab=pbias}
N 4310 1380 4340 1380 {
lab=avdd}
N 4640 1380 4670 1380 {
lab=iout}
N 4640 1400 4670 1400 {
lab=xxx}
N 590 1330 620 1330 {
lab=avss}
N 590 1310 620 1310 {
lab=nbias}
N 590 1290 620 1290 {
lab=ncbias}
N 590 1270 620 1270 {
lab=idir_sel}
N 590 1250 620 1250 {
lab=pcbias}
N 590 1230 620 1230 {
lab=sw0}
N 590 1210 620 1210 {
lab=pbias}
N 590 1190 620 1190 {
lab=avdd}
N 920 1190 950 1190 {
lab=iout}
N 920 1210 950 1210 {
lab=xxx}
N 590 1120 620 1120 {
lab=avss}
N 590 1100 620 1100 {
lab=nbias}
N 590 1080 620 1080 {
lab=ncbias}
N 590 1060 620 1060 {
lab=idir_sel}
N 590 1040 620 1040 {
lab=pcbias}
N 590 1020 620 1020 {
lab=sw0}
N 590 1000 620 1000 {
lab=pbias}
N 590 980 620 980 {
lab=avdd}
N 920 980 950 980 {
lab=iout}
N 920 1000 950 1000 {
lab=xxx}
N 590 930 620 930 {
lab=avss}
N 590 910 620 910 {
lab=nbias}
N 590 890 620 890 {
lab=ncbias}
N 590 870 620 870 {
lab=idir_sel}
N 590 850 620 850 {
lab=pcbias}
N 590 830 620 830 {
lab=sw0}
N 590 810 620 810 {
lab=pbias}
N 590 790 620 790 {
lab=avdd}
N 920 790 950 790 {
lab=iout}
N 920 810 950 810 {
lab=xxx}
N 590 720 620 720 {
lab=avss}
N 590 700 620 700 {
lab=nbias}
N 590 680 620 680 {
lab=ncbias}
N 590 660 620 660 {
lab=idir_sel}
N 590 640 620 640 {
lab=pcbias}
N 590 620 620 620 {
lab=sw0}
N 590 600 620 600 {
lab=pbias}
N 590 580 620 580 {
lab=avdd}
N 920 580 950 580 {
lab=iout}
N 920 600 950 600 {
lab=xxx}
N 590 530 620 530 {
lab=avss}
N 590 510 620 510 {
lab=nbias}
N 590 490 620 490 {
lab=ncbias}
N 590 470 620 470 {
lab=idir_sel}
N 590 450 620 450 {
lab=pcbias}
N 590 430 620 430 {
lab=sw0}
N 590 410 620 410 {
lab=pbias}
N 590 390 620 390 {
lab=avdd}
N 920 390 950 390 {
lab=iout}
N 920 410 950 410 {
lab=xxx}
N 590 340 620 340 {
lab=avss}
N 590 320 620 320 {
lab=nbias}
N 590 300 620 300 {
lab=ncbias}
N 590 280 620 280 {
lab=idir_sel}
N 590 260 620 260 {
lab=pcbias}
N 590 240 620 240 {
lab=sw0}
N 590 220 620 220 {
lab=pbias}
N 590 200 620 200 {
lab=avdd}
N 920 200 950 200 {
lab=iout}
N 920 220 950 220 {
lab=xxx}
N 590 150 620 150 {
lab=avss}
N 590 130 620 130 {
lab=nbias}
N 590 110 620 110 {
lab=ncbias}
N 590 90 620 90 {
lab=idir_sel}
N 590 70 620 70 {
lab=pcbias}
N 590 50 620 50 {
lab=sw0}
N 590 30 620 30 {
lab=pbias}
N 590 10 620 10 {
lab=avdd}
N 920 10 950 10 {
lab=iout}
N 920 30 950 30 {
lab=xxx}
N -930 30 -890 30 {}
N -930 50 -890 50 {}
N -930 70 -890 70 {}
N -930 90 -890 90 {}
N -590 30 -550 30 {}
N -930 150 -890 150 {}
N -930 170 -890 170 {}
N -930 190 -890 190 {}
N -930 210 -890 210 {}
N -590 150 -550 150 {}
N -930 260 -890 260 {}
N -930 280 -890 280 {}
N -930 300 -890 300 {}
N -930 320 -890 320 {}
N -590 260 -550 260 {}
N -930 380 -890 380 {}
N -930 400 -890 400 {}
N -930 420 -890 420 {}
N -930 440 -890 440 {}
N -590 380 -550 380 {}
N -930 510 -890 510 {}
N -930 530 -890 530 {}
N -930 550 -890 550 {}
N -930 570 -890 570 {}
N -590 510 -550 510 {}
N -930 630 -890 630 {}
N -930 650 -890 650 {}
N -930 670 -890 670 {}
N -930 690 -890 690 {}
N -590 630 -550 630 {}
N -590 50 -560 50 {}
N -590 170 -560 170 {}
N -590 280 -560 280 {}
N -590 400 -560 400 {}
N -590 530 -560 530 {}
N -590 650 -560 650 {}
C {icell1scs.sym} 130 80 0 0 {name=x1}
C {devices/lab_pin.sym} -50 10 0 0 {name=p1 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} -50 30 0 0 {name=p2 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} -50 50 0 0 {name=p3 sig_type=std_logic lab=sw0_1}
C {devices/lab_pin.sym} -50 70 0 0 {name=p4 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} -50 90 0 0 {name=p5 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} -50 110 0 0 {name=p6 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} -50 130 0 0 {name=p7 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} -50 150 0 0 {name=p8 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 310 10 0 1 {name=p9 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 310 30 0 1 {name=p10 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 130 270 0 0 {name=x2}
C {devices/lab_pin.sym} -50 200 0 0 {name=p11 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} -50 220 0 0 {name=p12 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} -50 240 0 0 {name=p13 sig_type=std_logic lab=sw2_3}
C {devices/lab_pin.sym} -50 260 0 0 {name=p14 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} -50 280 0 0 {name=p15 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} -50 300 0 0 {name=p16 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} -50 320 0 0 {name=p17 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} -50 340 0 0 {name=p18 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 310 200 0 1 {name=p19 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 310 220 0 1 {name=p20 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 130 460 0 0 {name=x3}
C {devices/lab_pin.sym} -50 390 0 0 {name=p21 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} -50 410 0 0 {name=p22 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} -50 450 0 0 {name=p24 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} -50 470 0 0 {name=p25 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} -50 490 0 0 {name=p26 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} -50 510 0 0 {name=p27 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} -50 530 0 0 {name=p28 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 310 390 0 1 {name=p29 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 310 410 0 1 {name=p30 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 130 660 0 0 {name=x4}
C {devices/lab_pin.sym} -50 590 0 0 {name=p31 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} -50 610 0 0 {name=p32 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} -50 630 0 0 {name=p33 sig_type=std_logic lab=sw4_7}
C {devices/lab_pin.sym} -50 650 0 0 {name=p34 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} -50 670 0 0 {name=p35 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} -50 690 0 0 {name=p36 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} -50 710 0 0 {name=p37 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} -50 730 0 0 {name=p38 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 310 590 0 1 {name=p39 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 310 610 0 1 {name=p40 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 130 860 0 0 {name=x5}
C {devices/lab_pin.sym} -50 790 0 0 {name=p41 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} -50 810 0 0 {name=p42 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} -50 850 0 0 {name=p44 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} -50 870 0 0 {name=p45 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} -50 890 0 0 {name=p46 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} -50 910 0 0 {name=p47 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} -50 930 0 0 {name=p48 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 310 790 0 1 {name=p49 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 310 810 0 1 {name=p50 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 130 1050 0 0 {name=x6}
C {devices/lab_pin.sym} -50 980 0 0 {name=p51 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} -50 1000 0 0 {name=p52 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} -50 1040 0 0 {name=p54 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} -50 1060 0 0 {name=p55 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} -50 1080 0 0 {name=p56 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} -50 1100 0 0 {name=p57 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} -50 1120 0 0 {name=p58 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 310 980 0 1 {name=p59 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 310 1000 0 1 {name=p60 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 130 1240 0 0 {name=x7}
C {devices/lab_pin.sym} -50 1170 0 0 {name=p61 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} -50 1190 0 0 {name=p62 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} -50 1230 0 0 {name=p64 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} -50 1250 0 0 {name=p65 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} -50 1270 0 0 {name=p66 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} -50 1290 0 0 {name=p67 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} -50 1310 0 0 {name=p68 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 310 1170 0 1 {name=p69 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 310 1190 0 1 {name=p70 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 130 1440 0 0 {name=x8}
C {devices/lab_pin.sym} -50 1370 0 0 {name=p71 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} -50 1390 0 0 {name=p72 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} -50 1410 0 0 {name=p73 sig_type=std_logic lab=sw8_15}
C {devices/lab_pin.sym} -50 1430 0 0 {name=p74 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} -50 1450 0 0 {name=p75 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} -50 1470 0 0 {name=p76 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} -50 1490 0 0 {name=p77 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} -50 1510 0 0 {name=p78 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 310 1370 0 1 {name=p79 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 310 1390 0 1 {name=p80 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 770 1450 0 0 {name=x16}
C {devices/lab_pin.sym} 590 1380 0 0 {name=p151 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 590 1400 0 0 {name=p152 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 590 1420 0 0 {name=p153 sig_type=std_logic lab=sw16_32}
C {devices/lab_pin.sym} 590 1440 0 0 {name=p154 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 590 1460 0 0 {name=p155 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 590 1480 0 0 {name=p156 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 590 1500 0 0 {name=p157 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 590 1520 0 0 {name=p158 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 950 1380 0 1 {name=p159 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 950 1400 0 1 {name=p160 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 1390 90 0 0 {name=x17}
C {devices/lab_pin.sym} 1210 20 0 0 {name=p161 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 1210 40 0 0 {name=p162 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 1210 60 0 0 {name=p163 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 1210 80 0 0 {name=p164 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 1210 100 0 0 {name=p165 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 1210 120 0 0 {name=p166 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 1210 140 0 0 {name=p167 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 1210 160 0 0 {name=p168 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 1570 20 0 1 {name=p169 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 1570 40 0 1 {name=p170 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 1390 280 0 0 {name=x18}
C {devices/lab_pin.sym} 1210 210 0 0 {name=p171 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 1210 230 0 0 {name=p172 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 1210 250 0 0 {name=p173 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 1210 270 0 0 {name=p174 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 1210 290 0 0 {name=p175 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 1210 310 0 0 {name=p176 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 1210 330 0 0 {name=p177 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 1210 350 0 0 {name=p178 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 1570 210 0 1 {name=p179 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 1570 230 0 1 {name=p180 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 1390 470 0 0 {name=x19}
C {devices/lab_pin.sym} 1210 400 0 0 {name=p181 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 1210 420 0 0 {name=p182 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 1210 440 0 0 {name=p183 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 1210 460 0 0 {name=p184 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 1210 480 0 0 {name=p185 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 1210 500 0 0 {name=p186 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 1210 520 0 0 {name=p187 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 1210 540 0 0 {name=p188 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 1570 400 0 1 {name=p189 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 1570 420 0 1 {name=p190 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 1390 670 0 0 {name=x20}
C {devices/lab_pin.sym} 1210 600 0 0 {name=p191 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 1210 620 0 0 {name=p192 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 1210 640 0 0 {name=p193 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 1210 660 0 0 {name=p194 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 1210 680 0 0 {name=p195 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 1210 700 0 0 {name=p196 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 1210 720 0 0 {name=p197 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 1210 740 0 0 {name=p198 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 1570 600 0 1 {name=p199 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 1570 620 0 1 {name=p200 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 1390 870 0 0 {name=x21}
C {devices/lab_pin.sym} 1210 800 0 0 {name=p201 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 1210 820 0 0 {name=p202 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 1210 840 0 0 {name=p203 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 1210 860 0 0 {name=p204 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 1210 880 0 0 {name=p205 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 1210 900 0 0 {name=p206 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 1210 920 0 0 {name=p207 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 1210 940 0 0 {name=p208 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 1570 800 0 1 {name=p209 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 1570 820 0 1 {name=p210 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 1390 1060 0 0 {name=x22}
C {devices/lab_pin.sym} 1210 990 0 0 {name=p211 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 1210 1010 0 0 {name=p212 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 1210 1030 0 0 {name=p213 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 1210 1050 0 0 {name=p214 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 1210 1070 0 0 {name=p215 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 1210 1090 0 0 {name=p216 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 1210 1110 0 0 {name=p217 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 1210 1130 0 0 {name=p218 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 1570 990 0 1 {name=p219 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 1570 1010 0 1 {name=p220 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 1390 1250 0 0 {name=x23}
C {devices/lab_pin.sym} 1210 1180 0 0 {name=p221 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 1210 1200 0 0 {name=p222 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 1210 1220 0 0 {name=p223 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 1210 1240 0 0 {name=p224 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 1210 1260 0 0 {name=p225 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 1210 1280 0 0 {name=p226 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 1210 1300 0 0 {name=p227 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 1210 1320 0 0 {name=p228 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 1570 1180 0 1 {name=p229 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 1570 1200 0 1 {name=p230 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 1390 1450 0 0 {name=x24}
C {devices/lab_pin.sym} 1210 1380 0 0 {name=p231 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 1210 1400 0 0 {name=p232 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 1210 1420 0 0 {name=p233 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 1210 1440 0 0 {name=p234 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 1210 1460 0 0 {name=p235 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 1210 1480 0 0 {name=p236 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 1210 1500 0 0 {name=p237 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 1210 1520 0 0 {name=p238 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 1570 1380 0 1 {name=p239 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 1570 1400 0 1 {name=p240 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 2030 90 0 0 {name=x25}
C {devices/lab_pin.sym} 1850 20 0 0 {name=p241 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 1850 40 0 0 {name=p242 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 1850 60 0 0 {name=p243 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 1850 80 0 0 {name=p244 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 1850 100 0 0 {name=p245 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 1850 120 0 0 {name=p246 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 1850 140 0 0 {name=p247 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 1850 160 0 0 {name=p248 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 2210 20 0 1 {name=p249 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 2210 40 0 1 {name=p250 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 2030 280 0 0 {name=x26}
C {devices/lab_pin.sym} 1850 210 0 0 {name=p251 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 1850 230 0 0 {name=p252 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 1850 250 0 0 {name=p253 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 1850 270 0 0 {name=p254 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 1850 290 0 0 {name=p255 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 1850 310 0 0 {name=p256 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 1850 330 0 0 {name=p257 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 1850 350 0 0 {name=p258 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 2210 210 0 1 {name=p259 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 2210 230 0 1 {name=p260 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 2030 470 0 0 {name=x27}
C {devices/lab_pin.sym} 1850 400 0 0 {name=p261 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 1850 420 0 0 {name=p262 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 1850 440 0 0 {name=p263 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 1850 460 0 0 {name=p264 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 1850 480 0 0 {name=p265 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 1850 500 0 0 {name=p266 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 1850 520 0 0 {name=p267 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 1850 540 0 0 {name=p268 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 2210 400 0 1 {name=p269 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 2210 420 0 1 {name=p270 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 2030 670 0 0 {name=x28}
C {devices/lab_pin.sym} 1850 600 0 0 {name=p271 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 1850 620 0 0 {name=p272 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 1850 640 0 0 {name=p273 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 1850 660 0 0 {name=p274 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 1850 680 0 0 {name=p275 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 1850 700 0 0 {name=p276 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 1850 720 0 0 {name=p277 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 1850 740 0 0 {name=p278 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 2210 600 0 1 {name=p279 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 2210 620 0 1 {name=p280 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 2030 870 0 0 {name=x29}
C {devices/lab_pin.sym} 1850 800 0 0 {name=p281 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 1850 820 0 0 {name=p282 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 1850 840 0 0 {name=p283 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 1850 860 0 0 {name=p284 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 1850 880 0 0 {name=p285 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 1850 900 0 0 {name=p286 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 1850 920 0 0 {name=p287 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 1850 940 0 0 {name=p288 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 2210 800 0 1 {name=p289 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 2210 820 0 1 {name=p290 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 2030 1060 0 0 {name=x30}
C {devices/lab_pin.sym} 1850 990 0 0 {name=p291 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 1850 1010 0 0 {name=p292 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 1850 1030 0 0 {name=p293 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 1850 1050 0 0 {name=p294 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 1850 1070 0 0 {name=p295 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 1850 1090 0 0 {name=p296 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 1850 1110 0 0 {name=p297 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 1850 1130 0 0 {name=p298 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 2210 990 0 1 {name=p299 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 2210 1010 0 1 {name=p300 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 2030 1250 0 0 {name=x31}
C {devices/lab_pin.sym} 1850 1180 0 0 {name=p301 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 1850 1200 0 0 {name=p302 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 1850 1220 0 0 {name=p303 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 1850 1240 0 0 {name=p304 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 1850 1260 0 0 {name=p305 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 1850 1280 0 0 {name=p306 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 1850 1300 0 0 {name=p307 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 1850 1320 0 0 {name=p308 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 2210 1180 0 1 {name=p309 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 2210 1200 0 1 {name=p310 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 2030 1450 0 0 {name=x32}
C {devices/lab_pin.sym} 1850 1380 0 0 {name=p311 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 1850 1400 0 0 {name=p312 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 1850 1420 0 0 {name=p313 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 1850 1440 0 0 {name=p314 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 1850 1460 0 0 {name=p315 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 1850 1480 0 0 {name=p316 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 1850 1500 0 0 {name=p317 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 1850 1520 0 0 {name=p318 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 2210 1380 0 1 {name=p319 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 2210 1400 0 1 {name=p320 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 2590 80 0 0 {name=x33}
C {devices/lab_pin.sym} 2410 10 0 0 {name=p321 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 2410 30 0 0 {name=p322 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 2410 50 0 0 {name=p323 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 2410 70 0 0 {name=p324 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 2410 90 0 0 {name=p325 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 2410 110 0 0 {name=p326 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 2410 130 0 0 {name=p327 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 2410 150 0 0 {name=p328 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 2770 10 0 1 {name=p329 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 2770 30 0 1 {name=p330 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 2590 270 0 0 {name=x34}
C {devices/lab_pin.sym} 2410 200 0 0 {name=p331 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 2410 220 0 0 {name=p332 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 2410 240 0 0 {name=p333 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 2410 260 0 0 {name=p334 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 2410 280 0 0 {name=p335 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 2410 300 0 0 {name=p336 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 2410 320 0 0 {name=p337 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 2410 340 0 0 {name=p338 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 2770 200 0 1 {name=p339 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 2770 220 0 1 {name=p340 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 2590 460 0 0 {name=x35}
C {devices/lab_pin.sym} 2410 390 0 0 {name=p341 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 2410 410 0 0 {name=p342 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 2410 430 0 0 {name=p343 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 2410 450 0 0 {name=p344 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 2410 470 0 0 {name=p345 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 2410 490 0 0 {name=p346 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 2410 510 0 0 {name=p347 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 2410 530 0 0 {name=p348 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 2770 390 0 1 {name=p349 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 2770 410 0 1 {name=p350 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 2590 660 0 0 {name=x36}
C {devices/lab_pin.sym} 2410 590 0 0 {name=p351 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 2410 610 0 0 {name=p352 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 2410 630 0 0 {name=p353 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 2410 650 0 0 {name=p354 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 2410 670 0 0 {name=p355 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 2410 690 0 0 {name=p356 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 2410 710 0 0 {name=p357 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 2410 730 0 0 {name=p358 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 2770 590 0 1 {name=p359 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 2770 610 0 1 {name=p360 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 2590 860 0 0 {name=x37}
C {devices/lab_pin.sym} 2410 790 0 0 {name=p361 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 2410 810 0 0 {name=p362 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 2410 830 0 0 {name=p363 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 2410 850 0 0 {name=p364 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 2410 870 0 0 {name=p365 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 2410 890 0 0 {name=p366 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 2410 910 0 0 {name=p367 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 2410 930 0 0 {name=p368 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 2770 790 0 1 {name=p369 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 2770 810 0 1 {name=p370 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 2590 1050 0 0 {name=x38}
C {devices/lab_pin.sym} 2410 980 0 0 {name=p371 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 2410 1000 0 0 {name=p372 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 2410 1020 0 0 {name=p373 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 2410 1040 0 0 {name=p374 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 2410 1060 0 0 {name=p375 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 2410 1080 0 0 {name=p376 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 2410 1100 0 0 {name=p377 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 2410 1120 0 0 {name=p378 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 2770 980 0 1 {name=p379 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 2770 1000 0 1 {name=p380 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 2590 1240 0 0 {name=x39}
C {devices/lab_pin.sym} 2410 1170 0 0 {name=p381 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 2410 1190 0 0 {name=p382 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 2410 1210 0 0 {name=p383 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 2410 1230 0 0 {name=p384 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 2410 1250 0 0 {name=p385 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 2410 1270 0 0 {name=p386 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 2410 1290 0 0 {name=p387 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 2410 1310 0 0 {name=p388 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 2770 1170 0 1 {name=p389 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 2770 1190 0 1 {name=p390 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 2590 1440 0 0 {name=x40}
C {devices/lab_pin.sym} 2410 1370 0 0 {name=p391 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 2410 1390 0 0 {name=p392 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 2410 1410 0 0 {name=p393 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 2410 1430 0 0 {name=p394 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 2410 1450 0 0 {name=p395 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 2410 1470 0 0 {name=p396 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 2410 1490 0 0 {name=p397 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 2410 1510 0 0 {name=p398 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 2770 1370 0 1 {name=p399 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 2770 1390 0 1 {name=p400 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 3230 90 0 0 {name=x41}
C {devices/lab_pin.sym} 3050 20 0 0 {name=p401 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 3050 40 0 0 {name=p402 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 3050 60 0 0 {name=p403 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 3050 80 0 0 {name=p404 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 3050 100 0 0 {name=p405 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 3050 120 0 0 {name=p406 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 3050 140 0 0 {name=p407 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 3050 160 0 0 {name=p408 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 3410 20 0 1 {name=p409 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 3410 40 0 1 {name=p410 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 3230 280 0 0 {name=x42}
C {devices/lab_pin.sym} 3050 210 0 0 {name=p411 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 3050 230 0 0 {name=p412 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 3050 250 0 0 {name=p413 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 3050 270 0 0 {name=p414 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 3050 290 0 0 {name=p415 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 3050 310 0 0 {name=p416 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 3050 330 0 0 {name=p417 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 3050 350 0 0 {name=p418 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 3410 210 0 1 {name=p419 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 3410 230 0 1 {name=p420 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 3230 470 0 0 {name=x43}
C {devices/lab_pin.sym} 3050 400 0 0 {name=p421 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 3050 420 0 0 {name=p422 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 3050 440 0 0 {name=p423 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 3050 460 0 0 {name=p424 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 3050 480 0 0 {name=p425 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 3050 500 0 0 {name=p426 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 3050 520 0 0 {name=p427 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 3050 540 0 0 {name=p428 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 3410 400 0 1 {name=p429 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 3410 420 0 1 {name=p430 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 3230 670 0 0 {name=x44}
C {devices/lab_pin.sym} 3050 600 0 0 {name=p431 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 3050 620 0 0 {name=p432 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 3050 640 0 0 {name=p433 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 3050 660 0 0 {name=p434 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 3050 680 0 0 {name=p435 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 3050 700 0 0 {name=p436 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 3050 720 0 0 {name=p437 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 3050 740 0 0 {name=p438 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 3410 600 0 1 {name=p439 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 3410 620 0 1 {name=p440 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 3230 870 0 0 {name=x45}
C {devices/lab_pin.sym} 3050 800 0 0 {name=p441 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 3050 820 0 0 {name=p442 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 3050 840 0 0 {name=p443 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 3050 860 0 0 {name=p444 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 3050 880 0 0 {name=p445 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 3050 900 0 0 {name=p446 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 3050 920 0 0 {name=p447 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 3050 940 0 0 {name=p448 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 3410 800 0 1 {name=p449 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 3410 820 0 1 {name=p450 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 3230 1060 0 0 {name=x46}
C {devices/lab_pin.sym} 3050 990 0 0 {name=p451 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 3050 1010 0 0 {name=p452 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 3050 1030 0 0 {name=p453 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 3050 1050 0 0 {name=p454 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 3050 1070 0 0 {name=p455 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 3050 1090 0 0 {name=p456 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 3050 1110 0 0 {name=p457 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 3050 1130 0 0 {name=p458 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 3410 990 0 1 {name=p459 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 3410 1010 0 1 {name=p460 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 3230 1250 0 0 {name=x47}
C {devices/lab_pin.sym} 3050 1180 0 0 {name=p461 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 3050 1200 0 0 {name=p462 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 3050 1220 0 0 {name=p463 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 3050 1240 0 0 {name=p464 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 3050 1260 0 0 {name=p465 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 3050 1280 0 0 {name=p466 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 3050 1300 0 0 {name=p467 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 3050 1320 0 0 {name=p468 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 3410 1180 0 1 {name=p469 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 3410 1200 0 1 {name=p470 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 3230 1450 0 0 {name=x48}
C {devices/lab_pin.sym} 3050 1380 0 0 {name=p471 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 3050 1400 0 0 {name=p472 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 3050 1420 0 0 {name=p473 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 3050 1440 0 0 {name=p474 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 3050 1460 0 0 {name=p475 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 3050 1480 0 0 {name=p476 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 3050 1500 0 0 {name=p477 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 3050 1520 0 0 {name=p478 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 3410 1380 0 1 {name=p479 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 3410 1400 0 1 {name=p480 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 3850 90 0 0 {name=x49}
C {devices/lab_pin.sym} 3670 20 0 0 {name=p481 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 3670 40 0 0 {name=p482 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 3670 60 0 0 {name=p483 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 3670 80 0 0 {name=p484 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 3670 100 0 0 {name=p485 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 3670 120 0 0 {name=p486 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 3670 140 0 0 {name=p487 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 3670 160 0 0 {name=p488 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 4030 20 0 1 {name=p489 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 4030 40 0 1 {name=p490 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 3850 280 0 0 {name=x50}
C {devices/lab_pin.sym} 3670 210 0 0 {name=p491 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 3670 230 0 0 {name=p492 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 3670 250 0 0 {name=p493 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 3670 270 0 0 {name=p494 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 3670 290 0 0 {name=p495 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 3670 310 0 0 {name=p496 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 3670 330 0 0 {name=p497 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 3670 350 0 0 {name=p498 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 4030 210 0 1 {name=p499 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 4030 230 0 1 {name=p500 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 3850 470 0 0 {name=x51}
C {devices/lab_pin.sym} 3670 400 0 0 {name=p501 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 3670 420 0 0 {name=p502 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 3670 440 0 0 {name=p503 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 3670 460 0 0 {name=p504 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 3670 480 0 0 {name=p505 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 3670 500 0 0 {name=p506 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 3670 520 0 0 {name=p507 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 3670 540 0 0 {name=p508 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 4030 400 0 1 {name=p509 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 4030 420 0 1 {name=p510 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 3850 670 0 0 {name=x52}
C {devices/lab_pin.sym} 3670 600 0 0 {name=p511 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 3670 620 0 0 {name=p512 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 3670 640 0 0 {name=p513 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 3670 660 0 0 {name=p514 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 3670 680 0 0 {name=p515 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 3670 700 0 0 {name=p516 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 3670 720 0 0 {name=p517 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 3670 740 0 0 {name=p518 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 4030 600 0 1 {name=p519 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 4030 620 0 1 {name=p520 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 3850 870 0 0 {name=x53}
C {devices/lab_pin.sym} 3670 800 0 0 {name=p521 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 3670 820 0 0 {name=p522 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 3670 840 0 0 {name=p523 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 3670 860 0 0 {name=p524 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 3670 880 0 0 {name=p525 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 3670 900 0 0 {name=p526 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 3670 920 0 0 {name=p527 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 3670 940 0 0 {name=p528 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 4030 800 0 1 {name=p529 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 4030 820 0 1 {name=p530 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 3850 1060 0 0 {name=x54}
C {devices/lab_pin.sym} 3670 990 0 0 {name=p531 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 3670 1010 0 0 {name=p532 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 3670 1030 0 0 {name=p533 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 3670 1050 0 0 {name=p534 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 3670 1070 0 0 {name=p535 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 3670 1090 0 0 {name=p536 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 3670 1110 0 0 {name=p537 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 3670 1130 0 0 {name=p538 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 4030 990 0 1 {name=p539 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 4030 1010 0 1 {name=p540 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 3850 1250 0 0 {name=x55}
C {devices/lab_pin.sym} 3670 1180 0 0 {name=p541 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 3670 1200 0 0 {name=p542 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 3670 1220 0 0 {name=p543 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 3670 1240 0 0 {name=p544 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 3670 1260 0 0 {name=p545 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 3670 1280 0 0 {name=p546 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 3670 1300 0 0 {name=p547 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 3670 1320 0 0 {name=p548 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 4030 1180 0 1 {name=p549 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 4030 1200 0 1 {name=p550 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 3850 1450 0 0 {name=x56}
C {devices/lab_pin.sym} 3670 1380 0 0 {name=p551 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 3670 1400 0 0 {name=p552 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 3670 1420 0 0 {name=p553 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 3670 1440 0 0 {name=p554 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 3670 1460 0 0 {name=p555 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 3670 1480 0 0 {name=p556 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 3670 1500 0 0 {name=p557 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 3670 1520 0 0 {name=p558 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 4030 1380 0 1 {name=p559 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 4030 1400 0 1 {name=p560 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 4490 90 0 0 {name=x57}
C {devices/lab_pin.sym} 4310 20 0 0 {name=p561 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 4310 40 0 0 {name=p562 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 4310 60 0 0 {name=p563 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 4310 80 0 0 {name=p564 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 4310 100 0 0 {name=p565 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 4310 120 0 0 {name=p566 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 4310 140 0 0 {name=p567 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 4310 160 0 0 {name=p568 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 4670 20 0 1 {name=p569 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 4670 40 0 1 {name=p570 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 4490 280 0 0 {name=x58}
C {devices/lab_pin.sym} 4310 210 0 0 {name=p571 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 4310 230 0 0 {name=p572 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 4310 250 0 0 {name=p573 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 4310 270 0 0 {name=p574 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 4310 290 0 0 {name=p575 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 4310 310 0 0 {name=p576 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 4310 330 0 0 {name=p577 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 4310 350 0 0 {name=p578 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 4670 210 0 1 {name=p579 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 4670 230 0 1 {name=p580 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 4490 470 0 0 {name=x59}
C {devices/lab_pin.sym} 4310 400 0 0 {name=p581 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 4310 420 0 0 {name=p582 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 4310 440 0 0 {name=p583 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 4310 460 0 0 {name=p584 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 4310 480 0 0 {name=p585 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 4310 500 0 0 {name=p586 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 4310 520 0 0 {name=p587 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 4310 540 0 0 {name=p588 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 4670 400 0 1 {name=p589 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 4670 420 0 1 {name=p590 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 4490 670 0 0 {name=x60}
C {devices/lab_pin.sym} 4310 600 0 0 {name=p591 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 4310 620 0 0 {name=p592 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 4310 640 0 0 {name=p593 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 4310 660 0 0 {name=p594 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 4310 680 0 0 {name=p595 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 4310 700 0 0 {name=p596 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 4310 720 0 0 {name=p597 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 4310 740 0 0 {name=p598 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 4670 600 0 1 {name=p599 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 4670 620 0 1 {name=p600 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 4490 870 0 0 {name=x61}
C {devices/lab_pin.sym} 4310 800 0 0 {name=p601 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 4310 820 0 0 {name=p602 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 4310 840 0 0 {name=p603 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 4310 860 0 0 {name=p604 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 4310 880 0 0 {name=p605 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 4310 900 0 0 {name=p606 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 4310 920 0 0 {name=p607 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 4310 940 0 0 {name=p608 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 4670 800 0 1 {name=p609 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 4670 820 0 1 {name=p610 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 4490 1060 0 0 {name=x62}
C {devices/lab_pin.sym} 4310 990 0 0 {name=p611 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 4310 1010 0 0 {name=p612 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 4310 1030 0 0 {name=p613 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 4310 1050 0 0 {name=p614 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 4310 1070 0 0 {name=p615 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 4310 1090 0 0 {name=p616 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 4310 1110 0 0 {name=p617 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 4310 1130 0 0 {name=p618 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 4670 990 0 1 {name=p619 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 4670 1010 0 1 {name=p620 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 4490 1250 0 0 {name=x63}
C {devices/lab_pin.sym} 4310 1180 0 0 {name=p621 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 4310 1200 0 0 {name=p622 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 4310 1220 0 0 {name=p623 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 4310 1240 0 0 {name=p624 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 4310 1260 0 0 {name=p625 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 4310 1280 0 0 {name=p626 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 4310 1300 0 0 {name=p627 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 4310 1320 0 0 {name=p628 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 4670 1180 0 1 {name=p629 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 4670 1200 0 1 {name=p630 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 4490 1450 0 0 {name=x64}
C {devices/lab_pin.sym} 4310 1380 0 0 {name=p631 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 4310 1400 0 0 {name=p632 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 4310 1420 0 0 {name=p633 sig_type=std_logic lab=sw0}
C {devices/lab_pin.sym} 4310 1440 0 0 {name=p634 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 4310 1460 0 0 {name=p635 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 4310 1480 0 0 {name=p636 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 4310 1500 0 0 {name=p637 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 4310 1520 0 0 {name=p638 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 4670 1380 0 1 {name=p639 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 4670 1400 0 1 {name=p640 sig_type=std_logic lab=ioutn}
C {devices/lab_pin.sym} -50 430 0 0 {name=p23 sig_type=std_logic lab=sw2_3}
C {devices/lab_pin.sym} -50 830 0 0 {name=p43 sig_type=std_logic lab=sw4_7}
C {devices/lab_pin.sym} -50 1020 0 0 {name=p53 sig_type=std_logic lab=sw4_7}
C {devices/lab_pin.sym} -50 1210 0 0 {name=p63 sig_type=std_logic lab=sw4_7}
C {icell1scs.sym} 770 1260 0 0 {name=x9}
C {devices/lab_pin.sym} 590 1190 0 0 {name=p81 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 590 1210 0 0 {name=p82 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 590 1230 0 0 {name=p83 sig_type=std_logic lab=sw8_15}
C {devices/lab_pin.sym} 590 1250 0 0 {name=p84 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 590 1270 0 0 {name=p85 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 590 1290 0 0 {name=p86 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 590 1310 0 0 {name=p87 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 590 1330 0 0 {name=p88 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 950 1190 0 1 {name=p89 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 950 1210 0 1 {name=p90 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 770 1050 0 0 {name=x10}
C {devices/lab_pin.sym} 590 980 0 0 {name=p91 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 590 1000 0 0 {name=p92 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 590 1020 0 0 {name=p93 sig_type=std_logic lab=sw8_15}
C {devices/lab_pin.sym} 590 1040 0 0 {name=p94 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 590 1060 0 0 {name=p95 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 590 1080 0 0 {name=p96 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 590 1100 0 0 {name=p97 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 590 1120 0 0 {name=p98 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 950 980 0 1 {name=p99 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 950 1000 0 1 {name=p100 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 770 860 0 0 {name=x11}
C {devices/lab_pin.sym} 590 790 0 0 {name=p101 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 590 810 0 0 {name=p102 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 590 830 0 0 {name=p103 sig_type=std_logic lab=sw8_15}
C {devices/lab_pin.sym} 590 850 0 0 {name=p104 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 590 870 0 0 {name=p105 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 590 890 0 0 {name=p106 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 590 910 0 0 {name=p107 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 590 930 0 0 {name=p108 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 950 790 0 1 {name=p109 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 950 810 0 1 {name=p110 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 770 650 0 0 {name=x12}
C {devices/lab_pin.sym} 590 580 0 0 {name=p111 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 590 600 0 0 {name=p112 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 590 620 0 0 {name=p113 sig_type=std_logic lab=sw8_15}
C {devices/lab_pin.sym} 590 640 0 0 {name=p114 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 590 660 0 0 {name=p115 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 590 680 0 0 {name=p116 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 590 700 0 0 {name=p117 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 590 720 0 0 {name=p118 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 950 580 0 1 {name=p119 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 950 600 0 1 {name=p120 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 770 460 0 0 {name=x14}
C {devices/lab_pin.sym} 590 390 0 0 {name=p131 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 590 410 0 0 {name=p132 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 590 430 0 0 {name=p133 sig_type=std_logic lab=sw8_15}
C {devices/lab_pin.sym} 590 450 0 0 {name=p134 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 590 470 0 0 {name=p135 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 590 490 0 0 {name=p136 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 590 510 0 0 {name=p137 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 590 530 0 0 {name=p138 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 950 390 0 1 {name=p139 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 950 410 0 1 {name=p140 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 770 270 0 0 {name=x15}
C {devices/lab_pin.sym} 590 200 0 0 {name=p141 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 590 220 0 0 {name=p142 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 590 240 0 0 {name=p143 sig_type=std_logic lab=sw8_15}
C {devices/lab_pin.sym} 590 260 0 0 {name=p144 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 590 280 0 0 {name=p145 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 590 300 0 0 {name=p146 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 590 320 0 0 {name=p147 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 590 340 0 0 {name=p148 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 950 200 0 1 {name=p149 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 950 220 0 1 {name=p150 sig_type=std_logic lab=ioutn}
C {icell1scs.sym} 770 80 0 0 {name=x65}
C {devices/lab_pin.sym} 590 10 0 0 {name=p641 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 590 30 0 0 {name=p642 sig_type=std_logic lab=pbias}
C {devices/lab_pin.sym} 590 50 0 0 {name=p643 sig_type=std_logic lab=sw8_15}
C {devices/lab_pin.sym} 590 70 0 0 {name=p644 sig_type=std_logic lab=pcbias}
C {devices/lab_pin.sym} 590 90 0 0 {name=p645 sig_type=std_logic lab=idir_sel}
C {devices/lab_pin.sym} 590 110 0 0 {name=p646 sig_type=std_logic lab=ncbias}
C {devices/lab_pin.sym} 590 130 0 0 {name=p647 sig_type=std_logic lab=nbias}
C {devices/lab_pin.sym} 590 150 0 0 {name=p648 sig_type=std_logic lab=avss}
C {devices/lab_pin.sym} 950 10 0 1 {name=p649 sig_type=std_logic lab=iout}
C {devices/lab_pin.sym} 950 30 0 1 {name=p650 sig_type=std_logic lab=ioutn}
C {devices/lab_pin.sym} -930 30 0 0 {name=p121 sig_type=std_logic lab=dvdd}
C {devices/lab_pin.sym} -930 50 0 0 {name=p122 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} -930 70 0 0 {name=p123 sig_type=std_logic lab=dlv0}
C {devices/lab_pin.sym} -930 90 0 0 {name=p124 sig_type=std_logic lab=dvss}
C {devices/lab_pin.sym} -550 30 0 1 {name=p125 sig_type=std_logic lab=dhv0}
C {devices/lab_pin.sym} -930 150 0 0 {name=p126 sig_type=std_logic lab=dvdd}
C {devices/lab_pin.sym} -930 170 0 0 {name=p127 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} -930 190 0 0 {name=p128 sig_type=std_logic lab=dlv1}
C {devices/lab_pin.sym} -930 210 0 0 {name=p129 sig_type=std_logic lab=dvss}
C {devices/lab_pin.sym} -550 150 0 1 {name=p130 sig_type=std_logic lab=dhv1}
C {devices/lab_pin.sym} -930 260 0 0 {name=p651 sig_type=std_logic lab=dvdd}
C {devices/lab_pin.sym} -930 280 0 0 {name=p652 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} -930 300 0 0 {name=p653 sig_type=std_logic lab=dlv2}
C {devices/lab_pin.sym} -930 320 0 0 {name=p654 sig_type=std_logic lab=dvss}
C {devices/lab_pin.sym} -550 260 0 1 {name=p655 sig_type=std_logic lab=dhv2}
C {devices/lab_pin.sym} -930 380 0 0 {name=p656 sig_type=std_logic lab=dvdd}
C {devices/lab_pin.sym} -930 400 0 0 {name=p657 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} -930 420 0 0 {name=p658 sig_type=std_logic lab=dlv3}
C {devices/lab_pin.sym} -930 440 0 0 {name=p659 sig_type=std_logic lab=dvss}
C {devices/lab_pin.sym} -550 380 0 1 {name=p660 sig_type=std_logic lab=dhv3}
C {devices/lab_pin.sym} -930 510 0 0 {name=p661 sig_type=std_logic lab=dvdd}
C {devices/lab_pin.sym} -930 530 0 0 {name=p662 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} -930 550 0 0 {name=p663 sig_type=std_logic lab=dlv4}
C {devices/lab_pin.sym} -930 570 0 0 {name=p664 sig_type=std_logic lab=dvss}
C {devices/lab_pin.sym} -550 510 0 1 {name=p665 sig_type=std_logic lab=dhv4}
C {devices/lab_pin.sym} -930 630 0 0 {name=p666 sig_type=std_logic lab=dvdd}
C {devices/lab_pin.sym} -930 650 0 0 {name=p667 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} -930 670 0 0 {name=p668 sig_type=std_logic lab=dlv5}
C {devices/lab_pin.sym} -930 690 0 0 {name=p669 sig_type=std_logic lab=dvss}
C {devices/lab_pin.sym} -550 630 0 1 {name=p670 sig_type=std_logic lab=dhv5}
C {lvhvbuffc.sym} -740 60 0 0 {name=x13}
C {lvhvbuffc.sym} -740 180 0 0 {name=x66}
C {lvhvbuffc.sym} -740 290 0 0 {name=x67}
C {lvhvbuffc.sym} -740 410 0 0 {name=x68}
C {lvhvbuffc.sym} -740 540 0 0 {name=x69}
C {lvhvbuffc.sym} -740 660 0 0 {name=x70}
C {devices/lab_pin.sym} -560 50 0 1 {name=p671 sig_type=std_logic lab=dhv0n}
C {devices/lab_pin.sym} -560 170 0 1 {name=p672 sig_type=std_logic lab=dhv1n}
C {devices/lab_pin.sym} -560 280 0 1 {name=p673 sig_type=std_logic lab=dhv2n}
C {devices/lab_pin.sym} -560 400 0 1 {name=p674 sig_type=std_logic lab=dhv3n}
C {devices/lab_pin.sym} -560 530 0 1 {name=p675 sig_type=std_logic lab=dhv4n}
C {devices/lab_pin.sym} -560 650 0 1 {name=p676 sig_type=std_logic lab=dhv5n}
